# IAR project test.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c stm8l15x.h stm8l15x_adc.c stm8l15x_adc.h stm8l15x_clk.c stm8l15x_clk.h stm8l15x_conf.h stm8l15x_dma.c stm8l15x_dma.h stm8l15x_gpio.c stm8l15x_gpio.h stm8l15x_it.c stm8l15x_it.h stm8l15x_syscfg.c stm8l15x_syscfg.h stm8l15x_tim1.c stm8l15x_tim1.h stm8l15x_tim2.c stm8l15x_tim2.h
